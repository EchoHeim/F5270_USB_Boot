# Keil uVision project tinyUSB_CHID.uvprojx, settings and files
target tinyUSB (6230000::V6.23::ARMCLANG)
  device: MM32F5277E7PV MindMotion
  pack: MindMotion.MM32F5277E_DFP.1.3.0
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: UID_ReadUID +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,CUSTOM_HSE_VAL,APP_TINYUSB,CFG_TUSB_MCU
  c include: ..\tinyUSB;..\tinyUSB\class\hid;..\tinyUSB\common;..\tinyUSB\device;..\CMSIS;..\CMSIS\Include;..\CMSIS\HAL_Lib\Inc;..\App_boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ..\CMSIS\MM32F5270.sct
  group STARTUP
    ../CMSIS/: startup_mm32f5270_keil.c system_mm32f5270.c
  group TinyUSB
    ../tinyUSB/: tusb.c
    ../tinyUSB/device/: usbd.c usbd_control.c
    ../tinyUSB/common/: tusb_fifo.c
    ../tinyUSB/class/hid/: hid_device.c
  group HAL_LIB
    ../CMSIS/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_enet.c hal_exti.c hal_flash.c hal_flexcan.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_qspi.c hal_rcc.c hal_rtc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_usbfs.c hal_wwdg.c
  group App_boot
    ../App_boot/: boot.c main.c mm32f5270_it.c platform.c tud_dcd_port.c usb_descriptors.c
