# Keil uVision project TinyUSB_Host_CDC_MSC_HID.uvprojx, settings and files
target TinyUSB_Host_CDC_MSC_HID (6230000::V6.23::ARMCLANG)
  device: MM32F5277E7PV MindMotion
  pack: MindMotion.MM32F5277E_DFP.1.3.0
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: TinyUSB_Host_CDC_MSC_HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER CFG_TUSB_MCU DCACHE_DISABLED CUSTOM_HSE_VAL
  c include: ..\CMSIS;..\CMSIS\Include;..\CMSIS\HAL_Lib\Inc;..\tinyUSB;..\..\TinyUSB_Host_CDC_MSC_HID;..\..\F5270_Host_CDC_MSC_HID;..\USB_Host
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ..\CMSIS\MM32F5270.sct
  link misc: --keep=*_cb
  group APP
    ../USB_Host/: cdc_app.c hid_app.c main.c mm32f5270_it.c msc_app.c platform.c tinyusb_host_cdc_msc_hid.c tud_dcd_port.c tuh_hcd_port.c
  group HAL_LIB
    ../CMSIS/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_enet.c hal_exti.c hal_flash.c hal_flexcan.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_qspi.c hal_rcc.c hal_rtc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_usbfs.c hal_wwdg.c
  group STARTUP
    ../CMSIS/: startup_mm32f5270_keil.c system_mm32f5270.c
  group TinyUSB
    ../tinyUSB/device/: usbd.c
    ../tinyUSB/host/: usbh.c hub.c
    ../tinyUSB/common/: tusb_fifo.c
    ../tinyUSB/: tusb.c
    ../tinyUSB/class/cdc/: cdc_device.c cdc_host.c
    ../tinyUSB/class/hid/: hid_host.c
    ../tinyUSB/class/msc/: msc_host.c
